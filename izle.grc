options:
  parameters:
    generate_options: no_gui
    id: izle
    output_language: python
    run_options: run
    title: h4ck3r PhD. 2022
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/Desktop/Sinyal
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: '20000000'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0000000000000000081c69dc3026771b
    bb_gain0: '0'
    bw0: 20e6
    freq0: 2437e6
    gain0: '47'
    gain_mode0: 'False'
    if_gain0: '14'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: 2437e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 2437e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_file_sink_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
